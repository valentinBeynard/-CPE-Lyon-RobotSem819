# Keil uVision project robot_V1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: robot_V1
  c flags: Optimize=2 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: commands.c commands.h commands_parser.c commands_parser.h main.c c8051F020.h debug.h serializer.c serializer.h motion.c motion.h distance_detector.c distance_detector.h spi_master.c
