# Keil uVision project SLAVE.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: SLAVE
  c flags: SizeSpeed=1
  group Source Group 1
    ./src/: spi_slave.c spi_slave.h c8051F020.h robot_slave.c slave_cmd.h light_beam.c light_beam.h sound_handler.c
    ./: STARTUP.A51 pointeur_lumineux.c pointeur_lumineux.h
